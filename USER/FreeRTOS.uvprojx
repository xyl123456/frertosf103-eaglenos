# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\MALLOC;..\HARDWARE\MESSAGE;..\CJSON;..\HARDWARE\MAX6675;..\HARDWARE\AD5676;..\HARDWARE\AD5933;..\HARDWARE\AD7124;..\HARDWARE\DetectBoard;..\HARDWARE\SPI;..\HARDWARE\SWITCH;..\HARDWARE\MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c user_process.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MAX6675/: max6675.c
    ../HARDWARE/AD5676/: AD5676.c
    ../HARDWARE/AD5933/: AD5933.c AD5933_I2C.c
    ../HARDWARE/AD7124/: AD7124.c platform_drivers.c
    ../HARDWARE/DetectBoard/: DetectBoard.c
    ../HARDWARE/SPI/: SPI1.c
    ../HARDWARE/SWITCH/: AnalogSwitch.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../STM32F10x_FWLib/src/: stm32f10x_dbgmcu.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group MALLOC
    ../MALLOC/: malloc.c
  group CJSON
    ../CJSON/: cJSON.c
